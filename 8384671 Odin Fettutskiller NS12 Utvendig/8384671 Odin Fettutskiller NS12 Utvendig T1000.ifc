Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: F:\\BRICSCAD\\Fettutskillere\\_BIM filer\\Fettutskiller utvendig\\8384671 Odin Fettutskiller NS12 Utvendig\\8384671 Odin Fettutskiller NS12 Utvendig T1000.ifc
Time: 2023-02-27T12:06:21
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 23.1.08
Made in: BricsCAD BIM 23.1.08
Authorization: Undefined

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Site
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
